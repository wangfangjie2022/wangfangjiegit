# Keil uVision project BaseStation.uvprojx, settings and files
target base_station (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IIKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: BaseStation_boot +hex
  AfterMake: fromelf.exe --bin -o obj\BaseStation_boot.bin obj\BaseStation_boot.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c misc: --gnu  -g  -W --diag_warning 1546
  c include: ..\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\alink;..\alink\xstar_2_0;..\system\include;..\Drivers\STM32_Cryptographic_Library\inc;..\Drivers\STM32_Cryptographic_Library\inc\AES;..\Drivers\STM32_Cryptographic_Library\inc\Common;..\Drivers\STM32_Cryptographic_Library\inc\AES\Common;..\Drivers\STM32_Cryptographic_Library\inc\AES\CBC;..\Inc\PT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x8020000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x24000010 size 0x7fff0
  memory RVCT10: RAM 0x24000000 size 0x10
  group Startup
    ../Src/: startup_stm32h743xx.s
  group User
    ../Src/: main.c Apitool.c crypt.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Task
    ../task/: power_task.c bat_manager_task.c update_task.c uart_task.c
  group Bsp
    ../Inc/: includes.h fun_opt.h bsp_uart.h bsp_flash.h bsp_adc.h bsp_i2c.h bsp_batt.h bsp_beep.h bsp_gpio.h bsp_led.h bsp_crypt.h
    ../system/include/: Sys_cfg.h
    ../Src/: bsp_uart.c bsp_flash.c bsp_iap.c bsp_adc.c bsp_i2c.c bsp_batt.c bsp_beep.c bsp_gpio.c bsp_led.c bsp_crypt.c
  group System
    ../system/: cqueue.c SystemTask.c
  group Drivers
    ../Inc/: stm32h7xx_hal_conf.h
    ../Src/: system_stm32h7xx.c
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_mdma.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_hal_cryp.c
software components: CMSIS:CORE 5.2.0
