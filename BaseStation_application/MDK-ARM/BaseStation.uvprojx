# Keil uVision project BaseStation.uvprojx, settings and files
target base_station (6120000::V6.12::.\ARMCLANG)
  device: STM32H743IIKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: BaseStation_app +hex
  AfterMake: fromelf.exe --bin -o obj\BaseStation_app.bin obj\BaseStation_app.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ..\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\alink;..\alink\xstar_2_0;..\system\include;..\Inc\PT;..\Base_RT_Fusion_lib\libfcs\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0xa0000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x24000010 size 0x7fff0
  memory RVCT10: RAM 0x24000000 size 0x10
  group Doc
    ../../: 需求说明.txt version.txt
  group User
    ../Src/: main.c stm32h7xx_it.c rtk_pos_set.c
    ../task/: power_task.c test_task.c bat_manager_task.c uart_task.c led_task.c rtk_manager_task.c update_task.c imagelink_task.c sys_util.c
    ../Inc/: imagelink_task.h sys_util.h
  group Bsp
    ../Inc/: includes.h fun_opt.h bsp_adc.h bsp_batt.h bsp_beep.h bsp_flash.h bsp_gpio.h bsp_i2c.h bsp_i2c_hw.h bsp_led.h bsp_uart.h bsp_lis3mdl.h bsp_mpu6500.h bsp_timer.h bsp_crc.h
    ../system/include/: Sys_cfg.h
    ../Src/: stm32h7xx_hal_msp.c Apitool.c bsp_iap.c bsp_adc.c bsp_batt.c bsp_beep.c bsp_flash.c bsp_gpio.c bsp_i2c.c bsp_i2c_hw.c bsp_led.c bsp_uart.c bsp_lis3mdl.c bsp_mpu6500.c bsp_timer.c bsp_crc.c
  group StdLib
    ../system/: cqueue.c SystemTask.c
  group HAL_Lib
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c
  group CMSIS
    ../Src/: system_stm32h7xx.c startup_stm32h743xx.s
  group Base_RT_Fusion_lib
    ../Base_RT_Fusion_lib/libfcs/lib/: ert_main.c plook_u32f_evencka.c Rotation_AHRS_GPS.c rt_invf2x2_snf.c rt_nonfinite.c rtGetInf.c rtGetNaN.c Translation_Fusion.c xstar_fcs.c
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib arm_cortexM7lfsp_math.lib
software components: CMSIS:CORE 5.2.0
